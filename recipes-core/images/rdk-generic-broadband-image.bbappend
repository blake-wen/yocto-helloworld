DESCRIPTION = "This is a customized version of the rdk-generic-broadband-image image available in \ 
               meta-turris this contains dev packages and installs the custom helloworld recipes  \
               present in meta-oem-blakecor."

IMAGE_INSTALL += "helloworld"



